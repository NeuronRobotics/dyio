# IAR project BSP.ewp, settings and files
configuration LPC11u14_MCB1000 (ARM, debug)
  General.OGChipSelectEditMenu: LPC11U14 NXP LPC11U14
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __LPC11UXX__; BOARD=BOARD_MCB1000
  ICCARM.CCIncludePath2: ..\CDL\CMSISv2p00_LPC11Uxx\lpcinc; ..\CDL\LPC11UxxLib\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: BSP.out
configuration LPC1768_MCB1700 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ICCARM.CCDefines: __LPC17XX__; BOARD=BOARD_MCB1700
  ICCARM.CCIncludePath2: ..\CDL\CMSISv2p00_LPC17xx\lpcinc; ..\CDL\LPC17xxLib\inc
  ICCARM.CCOptLevel: 0
configuration LPC1788_EAOEMBaseRevA (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  ICCARM.CCDefines: __LPC177X_8X__; BOARD=BOARD_EAOEMBase_RevA
  ICCARM.CCIncludePath2: ..\CDL\CMSISv2p00_LPC177x_8x\inc; ..\CDL\CMSISv2p00_LPC177x_8x\lpcinc; ..\CDL\LPC177x_8xLib\inc
configuration LPC1830_XPLORER (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1830 NXP LPC1830
  ICCARM.CCDefines: __LPC18XX__; BOARD=BOARD_XPLORER
  ICCARM.CCIncludePath2: ..\CDL\CMSISv2p00_LPC18xx\inc; ..\CDL\CMSISv2p00_LPC18xx\lpcinc; ..\CDL\LPC18xxLib\inc
configuration LPC1850_HITEX_A4 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  ICCARM.CCDefines: __LPC18XX__; BOARD=BOARD_HITEX_A4
  ICCARM.CCIncludePath2: as above
configuration LPC1857_MCB1800 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1857 NXP LPC1857
  ICCARM.CCDefines: __LPC18XX__; BOARD=BOARD_MCB1800_4300
  ICCARM.CCIncludePath2: as above
configuration LPC4330_Xplorer (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4330_M4 NXP LPC4330_M4
  ICCARM.CCDefines: __LPC43XX__; BOARD=BOARD_XPLORER
  ICCARM.CCIncludePath2: ..\CDL\CMSISv2p00_LPC43xx\inc; ..\CDL\LPC43xxLib\inc; ..\CDL\CMSISv2p00_LPC43xx\lpcinc
configuration LPC4350_HITEX_A4 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __LPC43XX__; BOARD=BOARD_HITEX_A4
  ICCARM.CCIncludePath2: ..\CDL\CMSISv2p00_LPC43xx\inc; ..\CDL\CMSISv2p00_LPC43xx\lpcinc; ..\CDL\LPC43xxLib\inc
configuration LPC4357_MCB4300 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  ICCARM.CCDefines: __LPC43XX__; BOARD=BOARD_MCB1800_4300
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    ./: bsp.c DataRam.c
  group EAOEMBaseRevA_LPC1788
    EAOEMBase_RevA/: bsp_EAOEMBase_RevA.c
  group HITEX
    HITEX/: bsp_HITEX.c
  group LPCXpressoBaseRevB
    LPCXpressoBase_RevB/: bsp_LPCXpressoBase_RevB.c
  group MCB1000
    MCB1000/: bsp_MCB1000.c
  group MCB1700
    MCB1700/: bsp_MCB1700.c
  group MCB1800_4300
    MCB1800_4300/: bsp_MCB1800_4300.c
  group Xplorer
    NGX/: bsp_NGX.c
