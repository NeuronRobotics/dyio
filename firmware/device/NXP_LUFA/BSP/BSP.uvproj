# Keil uVision project BSP.uvproj, settings and files
target MCB1000 (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: BSP_MCB1000 (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC11UXX__ BOARD=BOARD_MCB1000
  c include: ..\CDL\CMSISv2p00_LPC11Uxx\inc;..\CDL\CMSISv2p00_LPC11Uxx\lpcinc;..\CDL\LPC11UxxLib\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group common
    ./: bsp.c DataRam.c
    ./MCB1000/: bsp_MCB1000.c
    ./MCB1700/: bsp_MCB1700.c
    ./MCB1800_4300/: bsp_MCB1800_4300.c
    ./HITEX/: bsp_HITEX.c
    ./NGX/: bsp_NGX.c
    ./EAOEMBase_RevA/: bsp_EAOEMBase_RevA.c
target MCB1700 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: BSP_MCB1700 (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC17XX__ BOARD=BOARD_MCB1700
  c include: ..\CDL\CMSISv2p00_LPC17xx\inc;..\CDL\CMSISv2p00_LPC17xx\lpcinc;..\CDL\LPC17xxLib\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MCB1800 (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: BSP_MCB1800 (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC18XX__ BOARD=BOARD_MCB1800_4300
  c include: ..\CDL\CMSISv2p00_LPC18xx\inc;..\CDL\LPC18xxLib\inc
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
target MCB4300 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: BSP_MCB4300 (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC43XX__ BOARD=BOARD_MCB1800_4300
  c include: ..\CDL\CMSISv2p00_LPC43xx\inc;..\CDL\LPC43xxLib\inc;..\CDL\CMSISv2p00_LPC43xx\lpcinc
target HITEX1850 (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: as above
  output: BSP_HITEX1850 (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC18XX__ BOARD=BOARD_HITEX_A4
  c include: ..\CDL\CMSISv2p00_LPC18xx\inc;..\CDL\LPC18xxLib\inc
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
target HITEX4350 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: BSP_HITEX4350 (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC43XX__ BOARD=BOARD_HITEX_A4
  c include: ..\CDL\CMSISv2p00_LPC43xx\inc;..\CDL\CMSISv2p00_LPC43xx\lpcinc;..\CDL\LPC43xxLib\inc
target Xplorer1830 (ARM-ADS)
  device: LPC1830 NXP (founded by Philips)
  cpu: as above
  output: BSP_XPLORER1830 (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC18XX__ BOARD=BOARD_XPLORER
  c include: ..\CDL\CMSISv2p00_LPC18xx\inc;..\CDL\LPC18xxLib\inc
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
target Xplorer4330 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: BSP_XPLORER4330 (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC43XX__ BOARD=BOARD_XPLORER
  c include: as above
target Element14 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: BSP_ELE14_4350 (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC43XX__ BOARD=BOARD_ELE14_4350
  c include: as above
target EAOEMBaseRevA_LPC177x_8x (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: BSP_EAOEMBaseRevA_LPC177x_8x (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC177X_8X__ BOARD=BOARD_EAOEMBase_RevA
  c include: ..\CDL\CMSISv2p00_LPC177x_8x\inc;..\CDL\LPC177x_8xLib\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
