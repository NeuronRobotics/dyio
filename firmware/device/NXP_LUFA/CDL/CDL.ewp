# IAR project CDL.ewp, settings and files
configuration LPC11Uxx (ARM, debug)
  General.OGChipSelectEditMenu: LPC11U14 NXP LPC11U14
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __LPC11UXX__
  ICCARM.CCIncludePath2: CMSISv2p00_LPC11Uxx/lpcinc; LPC11UxxLib/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: CDL.out
configuration LPC17xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ICCARM.CCDefines: __LPC17XX__
  ICCARM.CCIncludePath2: LPC17xxLib\inc; CMSISv2p00_LPC17xx\lpcinc
configuration LPC43xx_M4 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCDefines: __LPC43XX__
  ICCARM.CCIncludePath2: .\CMSISv2p00_LPC43xx\inc; .\CMSISv2p00_LPC43xx\lpcinc; .\LPC43xxLib\inc
  ICCARM.CCOptStrategy: 1
configuration LPC18xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  ICCARM.CCDefines: __LPC18XX__
  ICCARM.CCIncludePath2: .\CMSISv2p00_LPC18xx\inc; .\CMSISv2p00_LPC18xx\lpcinc; .\LPC18xxLib\inc
configuration LPC177x_8x (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  ICCARM.CCDefines: __LPC177X_8X__
  ICCARM.CCIncludePath2: .\CMSISv2p00_LPC177x_8x\inc; .\CMSISv2p00_LPC177x_8x\lpcinc; .\LPC177x_8xLib\inc
  group CMSISv2p00_LPC11Uxx
    CMSISv2p00_LPC11Uxx/src/: core_cm0.c cstartup_M.s system_LPC11Uxx.c
  group CMSISv2p00_LPC177x_8x
    CMSISv2p00_LPC177x_8x/src/: core_cm3.c cstartup_M.s system_LPC177x_8x.c
  group CMSISv2p00_LPC18xx
    CMSISv2p00_LPC18xx/src/: cstartup_M.s init.c system_LPC18xx.c
  group CMSISv9p00_LPC17xx
    CMSISv2p00_LPC17xx/src/: core_cm3.c cstartup_M.s system_LPC17xx.c
  group CMSISv9p00_LPC43xx
    CMSISv2p00_LPC43xx/src/: core_cm4.c init.c startup_M.s system_LPC43xx.c
  group LPC11UxxLib/src
    LPC11UxxLib/src/: lpc11uxx_gpio.c lpc11uxx_i2c.c lpc11uxx_pinsel.c
  group LPC177x_8xLib
    LPC177x_8xLib/src/: debug_frmwrk.c lpc177x_8x_adc.c lpc177x_8x_bod.c lpc177x_8x_can.c lpc177x_8x_clkpwr.c lpc177x_8x_crc.c lpc177x_8x_dac.c lpc177x_8x_eeprom.c lpc177x_8x_emac.c lpc177x_8x_emc.c lpc177x_8x_exti.c lpc177x_8x_gpdma.c lpc177x_8x_gpio.c lpc177x_8x_i2c.c lpc177x_8x_i2s.c lpc177x_8x_iap.c lpc177x_8x_lcd.c lpc177x_8x_mci.c lpc177x_8x_mcpwm.c lpc177x_8x_nvic.c lpc177x_8x_pinsel.c lpc177x_8x_pwm.c lpc177x_8x_qei.c lpc177x_8x_rtc.c lpc177x_8x_ssp.c lpc177x_8x_systick.c lpc177x_8x_timer.c lpc177x_8x_uart.c lpc177x_8x_wwdt.c
  group LPC17xxLib/src
    LPC17xxLib/src/: lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_debug_frmwrk.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c
  group LPC18xxLib
    LPC18xxLib/src/: debug_frmwrk.c lpc18xx_adc.c lpc18xx_atimer.c lpc18xx_can.c lpc18xx_cgu.c lpc18xx_dac.c LPC18xx_debug_frmwrk.c lpc18xx_emc.c lpc18xx_evrt.c lpc18xx_gpdma.c lpc18xx_gpio.c lpc18xx_i2c.c lpc18xx_i2s.c lpc18xx_lcd.c lpc18xx_mcpwm.c lpc18xx_nvic.c lpc18xx_pwr.c lpc18xx_qei.c lpc18xx_rgu.c lpc18xx_rit.c lpc18xx_rtc.c lpc18xx_sct.c lpc18xx_scu.c lpc18xx_sdio.c lpc18xx_ssp.c lpc18xx_timer.c lpc18xx_uart.c lpc18xx_wwdt.c
  group LPC43xxLib/src
    LPC43xxLib/src/: Font5x7.c LCDTerm.c lpc43xx_adc.c lpc43xx_atimer.c lpc43xx_can.c lpc43xx_cgu.c lpc43xx_dac.c lpc43xx_emc.c lpc43xx_evrt.c lpc43xx_gpdma.c lpc43xx_gpio.c lpc43xx_i2c.c lpc43xx_i2s.c lpc43xx_lcd.c lpc43xx_mcpwm.c lpc43xx_nvic.c lpc43xx_pwr.c lpc43xx_qei.c lpc43xx_rgu.c lpc43xx_rit.c lpc43xx_rtc.c lpc43xx_sct.c lpc43xx_scu.c lpc43xx_ssp.c lpc43xx_timer.c lpc43xx_uart.c lpc43xx_wwdt.c sdio.c
